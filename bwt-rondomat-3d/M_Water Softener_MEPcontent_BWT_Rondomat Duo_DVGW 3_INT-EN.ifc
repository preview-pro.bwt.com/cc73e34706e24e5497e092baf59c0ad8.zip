Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: M_Water Softener_MEPcontent_BWT_Rondomat Duo_DVGW 3_INT-EN.ifc
Time: 2019-04-24T06:28:59
Author: admin
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
